Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: ELF2-JS90-0,6-TI.IFC
Time: 2025-08-01T14:32:55
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: 0000-003465-4-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 0000-004492-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 0000-004493-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 0000-004503-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9003-510000-1/9003-430100-2/Os³ona-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9003-510000-1/9003-430100-2/Przewód zlo¿enie-1/Os³ona przewodu-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9003-510000-1/9003-430100-4/Os³ona-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9003-510000-1/9003-510001-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9003-510000-1/9003-510001-2-solid2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9003-510000-1/9003-510002-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9003-510000-1/9003-510002-1-solid2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie4
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Kabel 1^3765-000000-1/Kabel^Kabel 1_3765-000000-1-solid2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Kabel 1^3765-000000-1/Osona^Kabel 1_3765-000000-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Kabel 1^3765-000000-1/Osona^Kabel 1_3765-000000-1-solid2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Kabel 2^3765-000000-1/Cable^Kabel 2_3765-000000-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Plomba fi10-1-solid1
In: Default Storey
PredefinedType: ELEMENT
